<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RTOS_03_EVENT.ewp</path>
  </project>
  <batchBuild />
</workspace>
